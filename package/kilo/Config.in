## package/kilo/Config.in
```kconfig
config KILO
bool "kilo><"
string "add kilo success~~" 
help
https://github.com/rebvivi/kilo
```
